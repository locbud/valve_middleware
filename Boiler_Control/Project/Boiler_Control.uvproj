# Keil uVision project Boiler_Control.uvproj, settings and files
target Boiler Control (MCS-51)
  device: MG82FG5B16 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0-0x02FF) CLOCK(25000000)
  output: Boiler_Client +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: MB_MT=0, Uart1=1, Uart2=0
  c include: ..\Source;..\Libraries
  group Source
    ../Libraries/: STARTUP.A51
    ../Source/: Boiler_Control.c
  group Libraries
    ../Libraries/: Time2.c UART.C Modbus.c CRC16.LIB SetDRV.c ADC.c IAP.C
  group Include
    ../Source/: Define.H
    ../Libraries/: CRC16.h REG_MG82FG5Bxx.h Time2.h UART.H SetDRV.h Modbus.h ADC.h IAP.H
target Boiler_Control_Master (MCS-51)
  device: MG82FG5B16 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0-0x02FF) CLOCK(25000000)
  output: Boiler_Server +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: MB_MT=1, Uart1=1, Uart2=0
  c include: ..\Source;..\Libraries
